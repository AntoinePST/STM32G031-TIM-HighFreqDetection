<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\6_ETR_TIM1TIM14.ewp</path>
  </project>
  <batchBuild />
</workspace>
